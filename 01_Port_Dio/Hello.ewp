# IAR project Hello.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT; AUTOSAR_OS_NOT_USED; IAR
  ICCARM.CCIncludePath2: ..\Startup; ..\include; Application; ebtresos\output\include; mcal\base\include; mcal\det\include; mcal\port\include; mcal\dio\include; mcal\rte\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Hello.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT
  ICCARM.CCIncludePath2: ..\Startup; ..\include; Application
  ILINK.IlinkIcfFile: ../config/S32K144_ram.icf
  group Application
    Application/: clocks_and_modes.c init.c init.h main.c
  group ebtresos
    ebtresos/output/src/: Dio_Cfg.c Port_Cfg.c Port_PBcfg.c
  group mcal/det
    mcal/det/src/: Det.c
  group mcal/dio
    mcal/dio/src/: Dio.c Dio_Gpio.c
  group mcal/port
    mcal/port/src/: Port.c Port_Ipw.c Port_Port_Ci.c
  group mcal/rte
    mcal/rte/src/: SchM_Dio.c SchM_Port.c
  group Startup
    ../Startup/: startup_S32K144.s system_S32K144.c
