# IAR project Hello.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K144 NXP S32K144
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT; AUTOSAR_OS_NOT_USED; IAR
  ICCARM.CCIncludePath2: ..\Startup; ..\include; Application; ebtresos\output\include; mcal\base\include; mcal\dem\include; mcal\det\include; mcal\dio\include; mcal\ecum\include; mcal\gpt\include; mcal\mcl\include; mcal\mcu\include; mcal\port\include; mcal\rte\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Hello.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM Debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_S32K144HFT0VLLT
  ICCARM.CCIncludePath2: ..\Startup; ..\include; Application
  ILINK.IlinkIcfFile: ../config/S32K144_ram.icf
  group Application
    Application/: clocks_and_modes.c init.c init.h main.c test.c test.h
  group ebtresos
    ebtresos/output/src/: CDD_Mcl_Cfg.c CDD_Mcl_PBcfg.c Dio_Cfg.c Gpt_Cfg.c Gpt_PBcfg.c Mcu_Cfg.c Mcu_PBcfg.c Port_Cfg.c Port_PBcfg.c
  group mcal/dem
    mcal/dem/src/: Dem.c
  group mcal/det
    mcal/det/src/: Det.c
  group mcal/dio
    mcal/dio/src/: Dio.c Dio_Gpio.c
  group mcal/ecum
    mcal/ecum/src/: EcuM.c
  group mcal/gpt
    mcal/gpt/src/: Gpt.c Gpt_Ftm.c Gpt_Ipw.c Gpt_LPit.c Gpt_Lptmr.c Gpt_SRtc.c
  group mcal/mcl
    mcal/mcl/src/: Ftm_Common.c LPit_Common.c Lptmr_Common.c
  group mcal/mcu
    mcal/mcu/src/: Mcu.c Mcu_CMU.c Mcu_CMU_Irq.c Mcu_CortexM4.c Mcu_IPW.c Mcu_IPW_Irq.c Mcu_PCC.c Mcu_PMC.c Mcu_PMC_Irq.c Mcu_RCM.c Mcu_RCM_Irq.c Mcu_SCG.c Mcu_SIM.c Mcu_SMC.c
  group mcal/port
    mcal/port/src/: Port.c Port_Ipw.c Port_Port_Ci.c
  group mcal/rte
    mcal/rte/src/: SchM_Dio.c SchM_Gpt.c SchM_Port.c
  group Startup
    ../Startup/: startup_S32K144.s system_S32K144.c
